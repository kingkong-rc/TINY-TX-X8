<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>LIB</name>
    <file>
      <name>$PROJ_DIR$\LIB\STM8L15x_StdPeriph_Driver\src\stm8l15x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\LIB\STM8L15x_StdPeriph_Driver\src\stm8l15x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\LIB\STM8L15x_StdPeriph_Driver\src\stm8l15x_usart.c</name>
    </file>
  </group>
  <group>
    <name>Menu</name>
    <file>
      <name>$PROJ_DIR$\Menu\FTDebug.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Menu\Menu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Menu\PowerOn.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Menu\StartUp.c</name>
    </file>
  </group>
  <group>
    <name>RF</name>
    <file>
      <name>$PROJ_DIR$\RF\CC2500.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\RF\FRSKYD16.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\adc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\beep.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\boot.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\ee.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\key.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\LED.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\SPI2.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\stm8l15x_it.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\tbc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\U3.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\uniqueID.c</name>
  </file>
</project>


