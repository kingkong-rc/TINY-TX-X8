<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FRSKYD8(2018-1-23).ewp</path>
  </project>
  <batchBuild/>
</workspace>


